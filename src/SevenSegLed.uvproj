# Keil uVision project SevenSegLed.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89LS52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(16000000) MODAT2
  output: SevenSegLed +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./src/: main.c seg.c timer.c Key.c DS1302.c buzzer.c ds18b20.c delay.c ExInterrupt.c PWM_LED.c
